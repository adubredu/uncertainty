Commit message: bounding box working

File: simulation/models/pepsi/pepsi.urdf (robot description, URDF)
Before this commit: robot pepsi.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.07 0.05 0.02; visual mesh filename=pepsi.stl scale=0.001 .001 .001
